FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"

hostname_append = "-host"
